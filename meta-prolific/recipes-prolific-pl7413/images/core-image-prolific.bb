inherit core-image
CORE_IMAGE_EXTRA_INSTALL:append = " prolific-pl7413"