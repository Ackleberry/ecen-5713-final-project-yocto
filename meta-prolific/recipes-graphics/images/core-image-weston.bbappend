IMAGE_INSTALL:append = " prolific-pl7413"