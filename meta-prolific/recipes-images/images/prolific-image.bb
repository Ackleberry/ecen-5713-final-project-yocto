require recipes-graphics/images/core-image-weston.bb

IMAGE_INSTALL:append = " prolific-pl7413"